# Keil uVision project RTOS.uvproj, settings and files
target RTOS (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: GPIO.c GPIO_Cfg.c main.c UART.c UART_Cnfg.c startup.s GPIO_Cfg.h UART.h GPIO.h UART_Cnfg.h
  group OS
    ./: SVC.c PendSV.c Semaphore.c OS.h OS.c Semaphore.h Task.h Task.c SVC.h List.h List.c SysTick.c SysTick.h M4MemMap.h Mutex.c Mutex.h Queue.c Queue.h
